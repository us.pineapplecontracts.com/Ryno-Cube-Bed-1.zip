Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2022-07-20T12:54:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.0.108 - Exporter 21.1.0.108 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 20 12:54:18 2022 * Host: BIRL-Lt * Database: C:\Users\BIR~1.LIM\AppData\Local\Temp\0461f6ef-4ae6-4c00-ba12-caba11d08c50\cf4912c5-70db-4811-844a-df8b66d9841d\ifc * Database version: 5507 * Database creation date: Wed Jul 20 12:54:13 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 20 12:54:14 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 20 12:54:14 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Family: Project Information; Numbering: Project Number; Organization Name: Issue Date; Postal Code: Project Name; Project Issue Date: ## Street City, State Zip; Units Format: Project Status; Values Displayed: Owner

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Family: Project Information; Numbering: Project Number; Organization Name: Issue Date; Postal Code: Project Name; Project Issue Date: ## Street City, State Zip; Units Format: Project Status; Values Displayed: Owner

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Family: Levels; Level: Level
Identity Data(Type) - Wrap between parameters only: 8mm Head
Pset_PropertyAgreement - Options: Level 1
Constraints - Structural: 0 mm
Dimensions - Wattage Comments: 0 mm
Identity Data - Computation Height: no; Level: yes; Options: Level 1
Other - Associated Datum: Level: 8mm Head; Family: Levels; Is Reference: Level: 8mm Head; Leader Type: Level: 8mm Head
Constraints(Type) - Light Emitter: Project Base Point
Graphics(Type) - All non 0 loads: 0; Area: Center; Fx 1: 1; Level: M_Level Head - Circle: M_Level Head - Circle; Name: yes; Wall Closure: no

# IfcBuildingElementProxy: Family1:Standard, Family1:Standard:206232
In: Level 1
Type - Material: Default
Type - Constraints - Is parametric: 0 mm
Type - Identity Data - Wrap between parameters only: Standard
Type - Other - Family: Generic Models; Level: Family1
Type - Pset_BuildingElementProxyCommon - Reference: Standard
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Length: 0 mm; Moves With Grids: 0 mm; Structural Usage: no
Dimensions - Curved Edge Condition: 3.00051 m2; IfcApplicationVersion: 0.483487 m3
Other - Associated Datum: Family1: Standard; Is Reference: Family1: Standard; Leader Type: Family1: Standard
Phasing - Average Modulus: New Construction
